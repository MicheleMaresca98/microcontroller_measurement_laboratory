# IAR project SinusoideValoreEfficaceDACADCDMAmezzoTrasferimento.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\..\..\..\..\Users\hp\Downloads\Libreria
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SinusoideValoreEfficaceDACADCDMAmezzoTrasferimento.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
    ../../../../../Downloads/Libreria/: startup_stm32f30x.s stm32f30x.h system_stm32f30x.c system_stm32f30x.h
